* gnetlist -g spice-sdb -o sample.sp sample.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
R1 0 3 1
R3 2 3 1
R2 1 2 1
V1 1 0 3
.end
